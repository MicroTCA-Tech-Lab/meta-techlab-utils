# DEFAULT_TIMEZONE is set hard (without "?=") to "Los Angeles" in meta-petalinux.
# The only way to override that is to do a .bbappend of our own
DEFAULT_TIMEZONE = "Europe/Berlin"
