
#MIRRORS_append = "\
#	git://git.eclipse.org/r/tcf/org.eclipse.tcf.agent.git;protocol=https \
#"

SRC_URI_remove = "git://git.eclipse.org/gitroot/tcf/org.eclipse.tcf.agent"
SRC_URI_prepend = " git://git.eclipse.org/r/tcf/org.eclipse.tcf.agent.git;protocol=https "

