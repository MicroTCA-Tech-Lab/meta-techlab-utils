# Override udhcpc script from upstream; make use of DHCP ntpsrv & hostname options
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
